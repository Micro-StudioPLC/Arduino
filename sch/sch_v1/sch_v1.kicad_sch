File: sch/sch_v1/sch_v1.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Performance & Correctness
Other:
- note added: "Computer | Web App"
- note removed: "Computer Software"
